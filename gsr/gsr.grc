options:
  parameters:
    author: Pierre Terrier - Original code Marcus Leech (CCERA)
    copyright: GNU-GPL
    description: A simple spectro radiometer for radiastronmy
    generate_options: qt_gui
    id: gsr
    output_language: python
    title: Gnuradio Spectro Radiometer
  states: {}

blocks:
- name: LMST
  id: variable_qtgui_label
  parameters:
    gui_hint: Main@0:1,3,1,1
    label: 'LMST :  '
    type: string
    value: ra_funcs.cur_sidereal(Longitude+tiktok).replace(",",":")
  states: {}
- name: Longitude
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@0:1,1,1,1
    label: 'Longitude : '
    min_len: '20'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: longitude
    widget: counter
  states: {}
- name: actual_freq
  id: variable
  parameters:
    value: ifreq
  states: {}
- name: alt
  id: variable
  parameters:
    value: '30.00'
  states: {}
- name: altitude
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@0:2,2,1,1
    label: 'Altitude :  '
    min_len: '20'
    start: '-180.00'
    step: '0.1'
    stop: '180.00'
    value: alt
    widget: counter
  states: {}
- name: amsl
  id: variable
  parameters:
    value: '600'
  states: {}
- name: azimut
  id: variable
  parameters:
    value: '180'
  states: {}
- name: correct_baseline
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: Main@0:3,1,1,1
    label: Baseline Correction
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: data_rate
  id: variable
  parameters:
    comment: |-
      The "back end" operates at this many Hz
      20Hz should be more than adequate for
      any data-logging requirements for this
      type of observing
    value: '10'
  states: {}
- name: dc_gain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: Main@0:5,3,1,1
    label: '"Detector Output Mult."'
    label0: x100
    label1: x1000
    label2: x10000
    label3: x100000
    label4: x1000000
    num_opts: '5'
    option0: '100'
    option1: '1000'
    option2: '10000'
    option3: '100000'
    option4: '1000000'
    orient: Qt.QHBoxLayout
    type: int
    value: '100'
    widget: radio_buttons
  states: {}
- name: decln
  id: variable
  parameters:
    value: altitude-latitude
  states: {}
- name: declnstr
  id: variable
  parameters:
    value: ' str("%3.2f" % decln) if (decln<0) else "+"+str("%3.2f" % (decln))'
  states: {}
- name: dophigh
  id: variable
  parameters:
    value: ((samp_rate/2.0)/ifreq)*299792.0
  states: {}
- name: doplow
  id: variable
  parameters:
    value: '-((samp_rate/2.0)/ifreq)*299792.0'
  states: {}
- name: fftrate
  id: variable
  parameters:
    value: int(samp_rate/fftsize)
  states: {}
- name: fftsize
  id: variable
  parameters:
    comment: |-
      We make this a variable, but in reality
      Embedded Python blocks
      dont handle runtime vector sizing very well
    value: '2048'
  states: {}
- name: filechoice
  id: variable_qtgui_chooser
  parameters:
    gui_hint: Main@0:3,3,1,1
    label: File type choice
    label0: No file
    label1: CSV file
    label2: ezRA file
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freqhigh
  id: variable
  parameters:
    value: (ifreq+(samp_rate/2.0))/1.0e6
  states: {}
- name: freqlow
  id: variable
  parameters:
    value: (ifreq-(samp_rate/2.0))/1.0e6
  states: {}
- name: freqstep
  id: variable
  parameters:
    value: (samp_rate/fftsize)/1.0e6
  states: {}
- name: gmt
  id: variable
  parameters:
    value: time.gmtime()
  states: {}
- name: idecln
  id: variable_qtgui_label
  parameters:
    gui_hint: Main@0:2,3,1,1
    label: 'Declination target :  '
    type: string
    value: declnstr
  states: {}
- name: ifreq
  id: variable_qtgui_entry
  parameters:
    gui_hint: Main@0:1,0,1,1
    label: Tuned Frequency
    type: real
    value: freq
  states: {}
- name: irfgain
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@0:2,0,1,1
    label: RF Gain
    min_len: '100'
    start: '0'
    step: '2.5'
    stop: '100'
    value: rfgain
    widget: counter
  states: {}
- name: isinteg
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@0:3,0,1,1
    label: Spectral Integration Time
    min_len: '100'
    start: '1'
    step: '1'
    stop: '300'
    value: sinteg
  states: {}
- name: itinteg
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@0:5,0,1,1
    label: TP Integration Time
    min_len: '100'
    start: '1'
    step: '1'
    stop: '300'
    value: tinteg
  states: {}
- name: latitude
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@0:2,1,1,1
    label: 'Latitude : '
    min_len: '20'
    start: '-90.00'
    step: '0.1'
    stop: '90.00'
    value: '44.695978'
    widget: counter
  states: {}
- name: ltp
  id: variable
  parameters:
    value: time.gmtime(time.time())
  states: {}
- name: pacer
  id: variable_function_probe
  parameters:
    block_id: pacer_probe
    comment: |-
      A bit of a hack to get us an LMST
      display that is updated at 1Hz
    function_name: level
    poll_rate: '1'
    value: '0.0'
  states: {}
- name: prefix
  id: variable
  parameters:
    value: ' "%3.2f" % (decln)'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: srate
  states: {}
- name: seconds
  id: variable
  parameters:
    value: '3600'
  states: {}
- name: split_ratio
  id: variable
  parameters:
    value: '100'
  states: {}
- name: tiktok
  id: variable
  parameters:
    value: pacer*0.0
  states: {}
- name: today
  id: variable
  parameters:
    value: '"%04d-%02d-%02d" % (gmt.tm_year, gmt.tm_mon, gmt.tm_mday)'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: Main@0:0,2,1,1
    label: Antenna Parameters
    type: string
    value: '""'
  states: {}
- name: variable_qtgui_label_1
  id: variable_qtgui_label
  parameters:
    gui_hint: Main@0:1,2,1,1
    label: 'Azimut : '
    type: string
    value: 180 ( meridian transit )
  states: {}
- name: variable_qtgui_label_3
  id: variable_qtgui_label
  parameters:
    gui_hint: Main@0:0,3,1,1
    label: Astronomy Parameters
    type: string
    value: '""'
  states: {}
- name: variable_qtgui_label_Location
  id: variable_qtgui_label
  parameters:
    gui_hint: Main@0:0,1,1,1
    label: Location Parameters
    type: string
    value: '""'
  states: {}
- name: variable_qtgui_label_rf
  id: variable_qtgui_label
  parameters:
    gui_hint: Main@0:0,0,1,1
    label: RF SDR Parameters
    type: string
    value: '""'
  states: {}
- name: velocity
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: Main@0:3,2,1,1
    label: Velocity / Frequency
    'true': '1'
    type: int
    value: vf
  states: {}
- name: winpower
  id: variable
  parameters:
    value: sum([x*x for x in window.blackman_harris(fftsize)])
  states: {}
- name: Main
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0
    label0: GSR
    num_tabs: '1'
  states: {}
- name: baseline_compensate
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Baseline compensator block
               Takes in an integrated FFT vector and either outputs that vector, or
               outputs a baseline-subtracted version of that vector
               
               fftsize - size of input vector
               collect - operate in "collect" rather than compensate mode
          """

          def __init__(self, fftsize=2048,collect=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Baseline Compensator',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=[(np.float32,fftsize)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.collect = collect
              self.fftbuf = np.zeros(fftsize,dtype=np.float32)

          def work(self, input_items, output_items):
              """Accumulate baseline data, apply corrections when asked"""
              if (self.collect == True):
                  #
                  # Collect samples, and compute a moving average on them
                  # They're already fairly-well smoothed, so we don't
                  # need to go overboard
                  #
                  for x in range(len(input_items[0])):
                      self.fftbuf = np.add(self.fftbuf, input_items[0][x])
                      self.fftbuf = np.divide(self.fftbuf, [2.0]*len(self.fftbuf))
                  self.avg = sum(self.fftbuf)/len(self.fftbuf)
                  self.avg *= 1.5
                  
                  for x in range(len(output_items[0])):
                      output_items[0][x] = input_items[0][x]
              else:
                  for x in range(len(output_items[0])):
                      output_items[0][x] = np.subtract(input_items[0][x], self.fftbuf)
                      output_items[0][x] = np.add(output_items[0][x], self.avg)
              
              return len(output_items[0])
    collect: True if correct_baseline == False else False
    comment: Optionally apply baseline-subtraction
    fftsize: fftsize
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: |-
      A detector
      Computes
      (I^2)+(Q^2)
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Convert to power estimate
    vlen: fftsize
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: split_ratio
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      After filtering, we don't need high
      sample rates
      reduce to 'data_rate' Hz
    n: int(int(samp_rate/data_rate)/split_ratio)
    type: float
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    comment: Decimate
    n: int(fftrate/data_rate)
    type: float
    vlen: fftsize
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    comment: Integrator doesn't reduce
    const: (1.0/split_ratio)*dc_gain
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: |-
      Turn into 10Log10
      Then scale appropriately
    k: '-20*math.log10(fftsize)-10*math.log10(winpower/fftsize)'
    n: '10'
    vlen: fftsize
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: fftsize
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: filechoice
    type: float
    vlen: fftsize
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      FFT requires fft-sized vectors
      we do that here
    num_items: fftsize
    type: complex
  states: {}
- name: dmult
  id: parameter
  parameters:
    label: Detector Multiplier
    type: eng_float
    value: '100'
  states: {}
- name: ezRAvectorlogger
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import ra_funcs

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Logging of vectors (like FFT outputs)
                fftsize - size of fft vector to log
                formatter - formatter function pointer
                filepat - pattern for beginning of filenaem
                extension - file extension
                logtime - how often to log (seconds)
                fmtstr - format string for data values
                localtime - whether to use local or UTC time
                fftshift - whether to shift FFT vector before logging
                longitude  - local longitude in decimal form
          """

          def __init__(self, fftsize=2048, formatter=None, filepat="foonly-%04d%02d%02d", extension=".csv",
              logtime=10, fmtstr="%11.9f", localtime=False, fftshift=False,longitude=2.55,legend=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='ezRA Vector Logger',   # will show up in GRC
                    in_sig=[(np.float32,fftsize)],
                  out_sig=None
              )
              
              self.formatter = formatter
              self.filepat = filepat
              self.extension = extension
              self.logtime = logtime
              self.fmtstr = fmtstr
              self.localtime = localtime
              self.vecavg = np.zeros(fftsize)
              self.now = time.time()
              self.fftshift = fftshift
              self.longitude = longitude
              self.legend = legend
              
              self.legcount = 0
              self.fn = ""
              self.curlegend = legend
              

          def work(self, input_items, output_items):
              """Log a vector into a file"""
              for x in range(len(input_items[0])):
                  self.vecavg = np.add(self.vecavg, input_items[0][x])
                  self.vecavg = np.divide(self.vecavg, [2.0]*len(self.vecavg))
              
              #
              # If time to log
              #
              if (time.time() - self.now >= self.logtime):
                  self.now = time.time()
                  #
                  # Decide on localtime or gmtime
                  #
                  if (self.localtime == True):
                      ltp = time.localtime()
                  else:
                      ltp = time.gmtime()

                  if (self.formatter == None):
                      fn = self.filepat % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday) + self.extension
                      fp = open(fn, "a")
                      #
                      # Filename has changed (new date) or
                      #  legend has changed (new DEC/FREQ/BW) or
                      #  legcount >= 30
                      #
                      wrlegend = False
                      if (self.fn != fn):
                          self.fn = fn
                          wrlegend = True
                      elif (self.curlegend != self.legend):
                          self.curlegend = self.legend
                          wrlegend = True
                      elif (self.legcount >= 30):
                          wrlegend = True
                          self.legcount = 0
                      if (wrlegend == True and self.legend != None):
                          self.legcount = 0
                          fp.close()
                          fn = self.filepat % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday) + self.extension
                          fp = open(fn, "w")
                          fp.write("from ezColgsr.py\n%s\n# times are in UTC\n# gain 49\n# frequency spectrums in dB power\n" % self.legend)
                                     
                      # If they specified a formatter function call it instead
                      #
                      if (self.formatter != None):
                          self.formatter(self.vecavg,self.filepat,self.extension)
                  
                      #
                      # Otherwise, do it here
                      #
                      else:
                          #
                          # Open the output file, with a name according to the filepat
                          #  specified
                          #
                          fp = open(self.filepat % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday) + self.extension, "a")
                         
                          #
                          # Write record header
                          #
                          fp.write ("%04d-%02d-%02dT%02d:%02d:%02d " % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday,ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
                          # fp.write ("%s," % ra_funcs.cur_sidereal(self.longitude))
                      
                          #
                          # Write each of the data items in the input vector
                          #
                      
                          #
                          # Check if they want us to  do an FFTSHIFT operation
                          #  (to  normalize the ordering of FFTW3 outputs)
                          #
                          if (self.fftshift == True):
                              l = len(self.vecavg)
                              l1 = list(self.vecavg[int(l/2):])
                              l2 = list(self.vecavg[0:int(l/2)])
                              lout = l1 + l2
                              lout = np.array(lout)
                          else:
                              lout = self.vecavg
                          for x in range(len(self.vecavg)):
                              fp.write(self.fmtstr % lout[x])
                              if (x < len(self.vecavg)-1):
                                  fp.write(" ")
                          fp.write("\n")
                          fp.close()
                  
                  
              return len(input_items[0])
    extension: '''.txt'''
    fftshift: 'False'
    fftsize: fftsize
    filepat: '''ezRA%04d%02d%02d''+''_''+prefix'
    fmtstr: '''%6.2f'''
    formatter: None
    legend: '"lat %g long %g amsl %g name %s\nfreqMin %g freqMax %g freqBinQty %g \n Azdeg %g Eldeg %g" % (latitude,Longitude,amsl,prefix,freqlow,freqhigh,fftsize,azimut,alt)'
    localtime: False if utc != 0 else True
    logtime: logtime*3
    longitude: longitude
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: flipper
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Flipper -- simply reverse the order of a vector
                     fftsize - size of the (probably FFT) vector
                     enabled - whether to flip or not
          """

          def __init__(self, fftsize=2048,enabled=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Flipper',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=[(np.float32,fftsize)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.enabled = enabled

          def work(self, input_items, output_items):
              """Flip order"""
              
              #
              # For each output item
              #
              # Either stuff it with flipped input, or non-flipped input
              #
              for x in range(len(output_items[0])):
                  if (self.enabled == True):
                      output_items[0][x] = input_items[0][x][::-1]
                  else:
                      output_items[0][x] = input_items[0][x]
              return len(output_items[0])
    comment: |-
      Optionally flip the spectral vector for
      display--for conventional display of
      redshift/blueshift
    enabled: 'False'
    fftsize: fftsize
  states: {}
- name: formatter
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import ra_funcs


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """A slow data textual formatter
                inputs are expected to be science-data
                   Parameters:
                      formatter - pointer to a custom formatter function
                      filepat - pattern used for formatting filename must provide converters for YYYY MM DD
                      extension - filename extension
                      logtime - how often to log, in seconds
                      fmtstr - formatter for data values -- most provide converters for both values
                      nchan - number of interleaved channels on input"""
                      
                      

          def __init__(self, formatter=None, filepat="foonly-%d%d%d", extension=".csv", 
              logtime=10,fmtstr="%11.9f",nchan=1,localtime=False,longitude=-76.03, legend=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BAA:Data Logger',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              #
              # Formatter is a function pointer--very often 'None'
              #
              self.formatter = formatter
              
              #
              # Controls the template for filename generation
              #
              self.filepat= filepat
              
              #
              # The filename extension
              #
              self.extension=extension
              
              #
              # The logging interval
              #
              self.logtime=logtime
              
              
              #
              # The data-item formatting string
              #      
              self.fmtstr = fmtstr
              
              #
              # How many (interleaved) channels
              self.nchan = nchan
              
              #
              # Use local time, rather than UTC/GMT?
              #
              self.localtime = localtime
              
              #
              # The averaing cells
              #
              self.avg = [0.0]*nchan
              self.acnt = [0]*nchan

              
              #
              # Keep track of the next channel's averaging cell we
              #  need to update
              #
              self.cndx = 0
              
              
              #
              # This isn't strictly required, since the work function code
              #  will take care of whatever items it gets presented with.
              #
              self.set_output_multiple(nchan)
              
              self.now = time.time()
              
              self.longitude = longitude
              
              self.legend = legend
              
              self.legcount = 0
              self.fn = ""
              self.curlegend = legend

          def work(self, input_items, output_items):
              
              if (self.localtime == False):
                  ltp = time.gmtime()
              else:
                  ltp = time.localtime()
              
              #
              # Distribute the input items over the averaging buffer as appropriate
              #  We assume that the input is interleaved by 'nchan'
              #  We use 'self.cndx' to keep track of which channel's averaging
              #  cell we need to put the next value in.
              #
              # Because GR's scheduler has no idea what our internal "shape"
              #  is, it can hand us many, or a few, items, every time we're
              #  called.
              #
              for x in range(len(input_items[0])):
                  self.avg[self.cndx % self.nchan] += input_items[0][x]
                  self.acnt[self.cndx % self.nchan] += 1
                  
                  #
                  # Increment and modularly reduce cndx
                  #
                  self.cndx += 1
                  self.cndx %= self.nchan
                  

              if ((time.time() - self.now) > self.logtime):
                  self.now = time.time()
                  if (self.formatter == None):
                      fn = self.filepat % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday) + self.extension
                      fp = open(fn, "a")
                      #
                      # Filename has changed (new date) or
                      #  legend has changed (new DEC/FREQ/BW) or
                      #  legcount >= 30
                      #
                      wrlegend = False
                      if (self.fn != fn):
                          self.fn = fn
                          wrlegend = True
                      elif (self.curlegend != self.legend):
                          self.curlegend = self.legend
                          wrlegend = True
                      elif (self.legcount >= 30):
                          #wrlegend = True
                          self.legcount = 0
                      if (wrlegend == True and self.legend != None):
                          self.legcount = 0
                          fp.write("INFO:%s\n" % self.legend)
                          
                      fp.write("%02d:%02d:%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
                      lmst = ra_funcs.cur_sidereal(self.longitude)
                      lmst = lmst.replace(",",":")
                      fp.write("%s," % lmst)
                      for x in range(self.nchan):
                          self.avg[x] /= self.acnt[x]
                          self.acnt[x] = 1
                          fp.write (self.fmtstr  % (self.avg[x]))
                          if (x < self.nchan-1):
                              fp.write(",")
                      fp.write("\n")
                      self.legcount += 1
                      
                          
                      fp.close()
        
                  else:
                      self.formatter(self.filepat,self.extension,self.avg[0],self.avg[1])
                  
              return len(input_items[0])
    extension: '''.csv'''
    filepat: '''tp-%04d%02d%02d''+''_''+prefix'
    fmtstr: '''%11.9f'''
    formatter: None
    legend: '"GMT,LMST,TP,DEC=%f,LONGITUDE=%f,LATITUDE=%f,AMSL=%f,FREQ=%f,BW=%f" % (decln,longitude,latitude,amsl,ifreq/1.0e6, srate/1.0e6)'
    localtime: False if utc != 0 else True
    logtime: logtime
    longitude: Longitude
    nchan: '1'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: RF Frequency (Hz)
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import ra_funcs
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: logtime
  id: parameter
  parameters:
    label: Logging Interval (secs)
    type: eng_float
    value: '5.0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: Longitude
    type: eng_float
    value: '2.552186'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The spectral sub-graph
      Compute the mag^2
      Integrate
      Decimate down to "data_rate"
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      The total-power sub-graph
      Compute mag^2 for both inputs
      (East and West)
      Provide East and West outputs
      as well as sum and difference
  states: {}
- name: note_2
  id: note
  parameters:
    comment: |-
      There are 32-bit-float numerical
      issues when using very-small ALPHA
      values in the IIR.
      So, we do the integration in two stages.
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: '"airspy=0,bias=1,pack=0"'
    bb_gain0: '20'
    freq0: actual_freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: pacer_probe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    alpha1: '1'
    autoscale: 'True'
    grid: 'True'
    gui_hint: Main@0:6,0,1,4
    label1: Sky
    name: '"Total Power (Daily)"'
    update_time: 1.0/(data_rate)
    vlen: '86400'
    width1: '2'
    x_axis_label: '"Drift Time  (Hours)"'
    x_start: '0'
    x_step: '-(1/3600)'
    x_units: ''
    y_axis_label: '"Detector Power"'
  states: {}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: Main@0:4,0,1,4
    label1: '"Spectrum"'
    name: '"Doppler Velocity" if (velocity == 1) else "Frequency"'
    showports: 'True'
    update_time: 1.0/(data_rate)
    vlen: fftsize
    x_axis_label: '"Red shift(km/s)"  if (velocity == 1) else  "Frequency (MHz)"'
    x_start: doplow if (velocity == True) else freqlow
    x_step: ((dophigh-doplow)/fftsize) if (velocity == 1) else freqstep
    x_units: '"km/s" if (velocity == 1) else "MHz"'
    y_axis_label: Rel power (dB)
    y_units: dB
    ymin: '-100'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain (dB)
    type: eng_float
    value: '49'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: ra_funcs.getalpha(1.0/itinteg,samp_rate/split_ratio)
    comment: A simple filter/integrator
    type: float
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: ra_funcs.getalpha(1.0/isinteg,fftrate)
    comment: Integrate
    type: float
    vlen: fftsize
  states: {}
- name: sinteg
  id: parameter
  parameters:
    label: Integraton Time(secs) for Spectrum
    type: eng_float
    value: '60.0'
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Sample Rate (SPS)
    type: eng_float
    value: 2.5e6
  states: {}
- name: stripchart_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """A strip chart takes in a stream of floats and produces a 1 hour long
             strip-chart as output
             
             Params:
                decim - how much to decimate input to produce 1 SPS
                daily - how many daily long is the stripchart vector
          """

          def __init__(self, decim=100,daily=86400):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Strip Chart daily',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[(np.float32,daily)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              #
              # How much do we need to average the input to produce a 1SPS
              #  output?
              #
              self.decim = decim
              
              #
              # The stripchart vector itself--must be persistent in the
              #  object instance
              #
              self.strip = [0.0]*daily
              
              #
              # keeps track of decimation
              #
              self.counter = 0
              
              #
              # We continuously average the input and store it here
              #
              self.avg = 0.0

          def general_work(self, input_items, output_items):
              """take an input item(s), place appropriately in stripchart output"""
       
              #
              # Our averager hasn't been initialized with a
              #  "prime the pump" value?
              # Do it now.
              #
              if (self.avg == 0.0):
                  self.avg = input_items[0][0]
                  self.counter = 0
                  #
                  # Also init the strip-chart to this level
                  #
                  self.strip = [self.avg]*len(self.strip)
              #
              # For each of the input items
              #
              for x in range(len(input_items[0])):
                  #
                  # Effectively we get a N-point moving average
                  # WHere "N" is "decim"
                  #
                  self.avg += input_items[0][x]
                  self.counter += 1
                  
                  #
                  # Time to output an item into the stripchart
                  #
                  if (self.counter >= self.decim):
                      
                      #
                      # Reduce by decim
                      #
                      self.avg /= self.counter
                      
                      #
                      # Use python array notation to effect a quick
                      #  shift of items in the stripchart array
                      #
                      self.strip = [self.avg] + self.strip[:-1]
                      self.counter = 0
                      self.avg = 1.0e-15
              #
              # Stuff output items with the contents of the 
              #  possibly-updated stripchart
              #
              for y in range(len(output_items[0])):
                  output_items[0][y] = self.strip
              
              #
              # Tell scheduler we consumed items
              #
              self.consume(0, len(input_items[0]))
              return len(output_items[0])
    comment: Produces a "stripchart" type vector
    daily: '86400'
    decim: data_rate
  states: {}
- name: tinteg
  id: parameter
  parameters:
    label: Integraton Time(secs) for TP
    type: eng_float
    value: '60'
  states: {}
- name: utc
  id: parameter
  parameters:
    label: Log in UTC time
    type: intx
    value: '1'
  states: {}
- name: vectorlogger
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import ra_funcs

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Logging of vectors (like FFT outputs)
                fftsize - size of fft vector to log
                formetter - formatter function pointer
                filepat - pattern for beginning of filenaem
                extension - file extension
                logtime - how often to log (seconds)
                fmtstr - format string for data values
                localtime - whether to use local or UTC time
                fftshift - whether to shift FFT vector before logging
                longitude  - local longitude in decimal form
          """

          def __init__(self, fftsize=2048, formatter=None, filepat="foonly-%04d%02d%02d", extension=".csv",
              logtime=10, fmtstr="%11.9f", localtime=False, fftshift=False,longitude=-76.03):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Vector Logger',   # will show up in GRC
                    in_sig=[(np.float32,fftsize)],
                  out_sig=None
              )
              
              self.formatter = formatter
              self.filepat = filepat
              self.extension = extension
              self.logtime = logtime
              self.fmtstr = fmtstr
              self.localtime = localtime
              self.vecavg = np.zeros(fftsize)
              self.now = time.time()
              self.fftshift = fftshift
              self.longitude = longitude

              

          def work(self, input_items, output_items):
              """Log a vector into a file"""
              for x in range(len(input_items[0])):
                  self.vecavg = np.add(self.vecavg, input_items[0][x])
                  self.vecavg = np.divide(self.vecavg, [2.0]*len(self.vecavg))
              
              #
              # If time to log
              #
              if (time.time() - self.now >= self.logtime):
                  self.now = time.time()
                  #
                  # Decide on localtime or gmtime
                  #
                  if (self.localtime == True):
                      ltp = time.localtime()
                  else:
                      ltp = time.gmtime()
                  
                  #
                  # If they specified a formatter function call it instead
                  #
                  if (self.formatter != None):
                      self.formatter(self.vecavg,self.filepat,self.extension)
                  
                  #
                  # Otherwise, do it here
                  #
                  else:
                      #
                      # Open the output file, with a name according to the filepat
                      #  specified
                      #
                      fp = open(self.filepat % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday) + self.extension, "a")
                      
                      #
                      # Write record header
                      #
                      fp.write ("%02d:%02d:%02d, " % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
                      lmst = ra_funcs.cur_sidereal(self.longitude)
                      lmst = lmst.replace(",",":")
                      fp.write("%s," % lmst)
                      # fp.write ("%s," % ra_funcs.cur_sidereal(self.longitude))            
                      #
                      # Write each of the data items in the input vector
                      #
                      
                      #
                      # Check if they want us to  do an FFTSHIFT operation
                      #  (to  normalize the ordering of FFTW3 outputs)
                      #
                      if (self.fftshift == True):
                          l = len(self.vecavg)
                          l1 = list(self.vecavg[int(l/2):])
                          l2 = list(self.vecavg[0:int(l/2)])
                          lout = l1 + l2
                          lout = np.array(lout)
                      else:
                          lout = self.vecavg
                      for x in range(len(self.vecavg)):
                          fp.write(self.fmtstr % lout[x])
                          if (x < len(self.vecavg)-1):
                              fp.write(",")
                      fp.write("\n")
                      fp.close()
                  
                  
              return len(input_items[0])
    extension: '''.csv'''
    fftshift: 'False'
    fftsize: fftsize
    filepat: '''fft-%04d%02d%02d''+''_''+prefix'
    fmtstr: '''%6.2f'''
    formatter: None
    localtime: False if utc != 0 else True
    logtime: logtime*3
    longitude: longitude
  states: {}
- name: vf
  id: parameter
  parameters:
    type: intx
    value: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rf1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rf1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: rf1
  states: {}

connections:
- [baseline_compensate, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_1, '0', single_pole_iir_filter_xx_1, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', formatter, '0']
- [blocks_keep_one_in_n_0, '0', stripchart_0, '0']
- [blocks_keep_one_in_n_1, '0', baseline_compensate, '0']
- [blocks_multiply_const_xx_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_selector_0, '0']
- [blocks_nlog10_ff_0, '0', flipper, '0']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', vectorlogger, '0']
- [blocks_selector_0, '2', ezRAvectorlogger, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [flipper, '0', qtgui_vector_sink_f_1, '0']
- [osmosdr_source_1, '0', virtual_sink_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [single_pole_iir_filter_xx_0, '0', pacer_probe, '0']
- [single_pole_iir_filter_xx_1, '0', blocks_keep_one_in_n_1, '0']
- [stripchart_0, '0', qtgui_vector_sink_f_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
